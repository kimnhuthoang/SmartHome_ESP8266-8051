# Keil uVision project 8051_SmartHome.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 8051_SmartHome
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: main.c DelayTimer0.c eeprom_24Cxx.c i2c_lcd.c mfrc522.c soft_i2c.c UartMode1.c
